# Keil uVision project PB10A-General_PowerBank.uvprojx, settings and files
target PB10A-General_PowerBank (6240000::V6.24::ARMCLANG)
  device: STM32G070KBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PB10A-General_PowerBank +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G070xx,SC7A20_USE_FLOAT_API=0,BMP180_USE_FLOAT_API=0,SW6306_USE_FLOAT_API=0,COROOS_USE_IDLE_SLEEP=1
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../APP;../Scheduler;../Scheduler/pt1.4;../APP/framework;../APP/algorithm;../APP/functions;../APP/MiaoUI;../BSP/Display;../BSP/Time;../BSP/u8g2;../BSP/SW6306;../BSP/SC7A20;../BSP/RDA5807;../BSP/BMP180;../BSP/MMC5603;../BSP/Buttons;../LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\Ld\PB10A-General_PowerBank.sct
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c i2c.c rtc.c spi.c tim.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_gpio.c stm32g0xx_ll_exti.c stm32g0xx_ll_adc.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_utils.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_ll_crc.c stm32g0xx_ll_i2c.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_ll_spi.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Application/APP
    ../Scheduler/: coroOS.c
    ../APP/: app_task.c i18n.c
    ../APP/framework/: pm_api.c pm_controller.c pm_device.c pm_device_builtin.c pm_policy.c pm_sleep_timer.c time_service.c beep_service.c
    ../APP/functions/: i2c_scanner.c powerbank_app.c radio_app.c tools_motion_app.c
    ../APP/algorithm/: system_algo.c power_algo.c wled_algo.c sc7a20_algo.c mmc5603_algo.c bmp180_algo.c radio_algo.c fault_record.c
    ../APP/functions/games/arkanoid/: game_arkanoid.c
    ../APP/functions/games/tetris/: game_tetris.c tetris_assets.c
    ../APP/functions/games/pacman/: game_pacman.c pacman_core.c pacman_assets.c
    ../APP/functions/games/: game_shared.c
    ../APP/functions/games/bomber/: game_bomber.c bomber_core.c bomber_assets.c
    ../APP/functions/games/invaders/: game_invaders.c invaders_core.c invaders_assets.c
  group BSP/Buttons
    ../BSP/Buttons/: buttons.c
  group Application/MiaoUI
    ../APP/MiaoUI/core/: ui.c
    ../APP/MiaoUI/display/: dispDriver.c
    ../APP/MiaoUI/indev/: indevDriver.c
    ../APP/MiaoUI/images/: image.c
    ../APP/MiaoUI/widget/: parameter.c text.c
    ../APP/MiaoUI/: ui_conf.c
    ../APP/MiaoUI/fonts/: font_fusion_pixel_p12_zhcn.c font_radio_h24w12.c font_home_h6w4.c
  group Application/LIB
    ../LIB/: rle.c fifo.c mini_format.c mini_math.c
  group Application/BSP
    ../BSP/Display/: ssd1306_display.c
    ../BSP/SW6306/: sw6306.c
    ../BSP/SC7A20/: sc7a20.c
    ../BSP/RDA5807/: rda5807m.c
    ../BSP/Time/: millis.c
    ../BSP/BMP180/: bmp180.c
    ../BSP/MMC5603/: mmc5603.c
  group BSP/u8g2
    ../BSP/u8g2/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_hvline.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_setup.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_d_ssd1306_128x64_noname.c u8x8_display.c u8x8_gpio.c u8x8_setup.c u8x8_string.c
software components: CMSIS:CORE 6.2.0
